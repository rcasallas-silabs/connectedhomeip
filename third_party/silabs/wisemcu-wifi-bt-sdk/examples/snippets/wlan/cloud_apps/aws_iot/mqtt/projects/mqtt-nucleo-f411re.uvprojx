# Keil uVision project mqtt-nucleo-f411re.uvprojx, settings and files
target aws_iot_mqtt (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: aws_iot_mqtt
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: MQTT_YIELD_EN EXECUTION_FROM_RAM USE_HAL_DRIVER STM32F411xE RSI_DEBUG_PRINTS RSI_WLAN_API_ENABLE RSI_WITH_OS WISECONNECT RSI_SAMPLE_HAL RSI_DEBUG_PRINTS RSI_WLAN_ENABLE CHIP_9117
  c misc: --C99 --reduce_paths
  c include: ../../../../../../../examples/snippets/wlan/cloud_apps/aws_iot/mqtt;../../../../../../../sapi/include; ../../../../../../../sapi/network/protocols; ../../../../../../../platforms/stm32/drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../../../platforms/stm32/drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../../../platforms/stm32/drivers/CMSIS/Include; ../../../../../../../platforms/stm32/drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../../../platforms/stm32/core/inc; ../../../../../../../platforms/stm32/boards/nucleo-f411re; ../../../../../../../sapi/network/protocols; ../../../../../../../resources/certificates; ../../../../../../../third_party/aws_sdk/include; ../../../../../../../third_party/aws_sdk/platform/silabs/inc; ../../../../../../../third_party/freertos/include; ../../../../../../../third_party/freertos/portable; ../../../../../../../sapi/rtos/freertos_wrapper; platforms/stm32/boards/nucleo-f411re
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329 --reduce_paths
  group example
    ../../../../../../../examples/snippets/wlan/cloud_apps/aws_iot/mqtt/: rsi_subscribe_publish_sample.c rsi_wlan_config.h aws_iot_config.h
  group platform/stm32
    ../../../../../../../platforms/stm32/hal/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_sdio.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c rsi_hal_mcu_rtc.c sl_hal_mcu_logging.c
    ../../../../../../../platforms/stm32/drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
    ../../../../../../../platforms/stm32/core/src/: system_stm32f4xx.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../../../../../../../platforms/stm32/core/startup/: startup_stm32f411xe.s
  group platform/nucleo-f411re
    ../../../../../../../platforms/stm32/boards/nucleo-f411re/: rsi_board_configuration.h
  group sapi/core
    ../../../../../../../sapi/common/: rsi_common_apis.c rsi_device_init_apis.c rsi_apis_rom.c rsi_apis_non_rom.c
    ../../../../../../../sapi/crypto/: rsi_crypto.c
    ../../../../../../../sapi/driver/: rsi_iap.c rsi_device_init.c rsi_queue.c rsi_common.c rsi_os_none.c rsi_driver_event_handlers.c rsi_scheduler.c rsi_bt_ble.c rsi_utils.c rsi_driver.c rsi_events.c rsi_timer.c rsi_setregion_countryinfo.c rsi_pkt_mgmt.c rsi_utils_rom.c rsi_pkt_mgmt_rom.c rsi_scheduler_rom.c rsi_queue_rom.c rsi_events_rom.c rsi_nwk.c rsi_wlan.c
    ../../../../../../../sapi/driver/device_interface/sdio/: rsi_sdio_mem_rd_wr.c rsi_sdio_iface_init.c rsi_sdio_frame_rd_wr.c rsi_sdio_reg_rd_wr.c
    ../../../../../../../sapi/driver/device_interface/spi/: rsi_spi_reg_rd_wr.c rsi_spi_frame_rd_wr.c rsi_spi_iface_init.c rsi_spi_functs.c rsi_spi_mem_rd_wr.c
    ../../../../../../../sapi/driver/device_interface/uart/: rsi_uart.c
    ../../../../../../../sapi/network/socket/: rsi_socket.c rsi_socket_rom.c
    ../../../../../../../sapi/wlan/: rsi_wlan_apis.c
    ../../../../../../../sapi/logging/: sl_app_logging.c sl_fw_logging.c
    ../../../../../../../utilities/advanced_logging/firmware_logging/: firmware_logging_utils.c
  group sapi/sockets
    ../../../../../../../sapi/network/protocols/: rsi_dns.c rsi_emb_mqtt_client.c rsi_raw_data.c rsi_http_ota_fw_up.c rsi_dhcp_user_class.c
  group third_party/aws
    ../../../../../../../third_party/aws_sdk/platform/silabs/src/: timer.c network_sapi_wrapper.c
    ../../../../../../../third_party/aws_sdk/src/: aws_iot_jobs_topics.c aws_iot_jobs_json.c aws_iot_jobs_interface.c aws_iot_mqtt_client_yield.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_publish.c aws_iot_shadow.c aws_iot_mqtt_client.c aws_iot_mqtt_client_common_internal.c aws_iot_shadow_records.c aws_iot_shadow_json.c aws_iot_jobs_types.c jsmn.c aws_iot_mqtt_client_connect.c aws_iot_json_utils.c aws_iot_shadow_actions.c
  group sapi/freertos
    ../../../../../../../sapi/rtos/freertos_wrapper/: rsi_os_wrapper.c port.c portmacro.h
  group third_party/freertos
    ../../../../../../../third_party/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../../third_party/freertos/portable/MemMang/: heap_4.c
